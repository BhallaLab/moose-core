* AUTOGENERATED MOOSE-MODEL IN SPICE.
* GENERATED ON: 2014-05-12-2352
.SUBCKT moose_compartment in1 in2 inject out1 out2 Ra=10k Rm=10G Cm=10pF Em=-60m
Ra1 in1 inject {Ra/2}
Ra2 inject out1 {Ra/2}
Cm inject in2 {Cm}
Rm inject _rm_cm_node {Rm}
VEm out2 _rm_cm_node dc {Em}
.ENDS

X_cable_0__a_0_ n_cable_0__a_0_in1 GND n_cable_0__a_0_inject n_cable_0__a_0_out1 GND  moose_compartment Ra=1.0 Rm=1.0 Cm=1.0 Em=-0.06
V_cable_0__a_0__cable_0__b_0_ n_cable_0__a_0_out1 n_cable_0__b_0_in1 dc 0
X_cable_0__b_0_ n_cable_0__b_0_in1 GND n_cable_0__b_0_inject n_cable_0__b_0_out1 GND  moose_compartment Ra=1.0 Rm=1.0 Cm=1.0 Em=-0.06

** Current pulses from moose
I0_pulse1_0_ n_cable_0__a_0__inject GND PULSE(0.0 1e-09 0.01 0.0 0.0 0.1 0.19)
